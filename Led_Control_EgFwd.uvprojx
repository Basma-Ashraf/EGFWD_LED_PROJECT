# Keil uVision project Led_Control_EgFwd.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Led_Control_EgFwd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\COTS\APP;.\COTS\Common;.\COTS\Config;.\COTS\MCAL\DIO;.\COTS\MCAL\INC;.\COTS\MCAL\NVIC;.\COTS\MCAL\RCC;.\COTS\MCAL\SYSTICK;.\COTS\MCAL\WDT
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./Drivers/MCAL/DIO/: MCAL_DIO.c MCAL_PORT.c
    ./Drivers/MCAL/NVIC/: NVIC.c
    ./Drivers/MCAL/RCC/: RCC.c
    ./Drivers/MCAL/SYSTICK/: systick.c
  group APPLICATION
    ./Drivers/APP/: main.c
  group CONFIGRATION
    ./Drivers/Config/: IntCtrl_cfg.c MCAL_Port_Config.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
