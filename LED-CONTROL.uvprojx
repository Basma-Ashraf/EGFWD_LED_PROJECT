# Keil uVision project LED-CONTROL.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED-CONTROL
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\EGFWD_Advanced_Embedded\Source Code\Common;.\EGFWD_Advanced_Embedded\Source Code\Config;.\EGFWD_Advanced_Embedded\Source Code\MCAL\INC;.\EGFWD_Advanced_Embedded\Source Code\MCAL\DIO;.\EGFWD_Advanced_Embedded\Source Code\MCAL\RCC;.\EGFWD_Advanced_Embedded\Source Code\MCAL\SYSTICK;.\EGFWD_Advanced_Embedded\Source Code\APP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./EGFWD_Advanced_Embedded/Source Code/MCAL/: IntCtrl.c
    ./EGFWD_Advanced_Embedded/Source Code/MCAL/DIO/: MCAL_DIO.c MCAL_PORT.c
    ./EGFWD_Advanced_Embedded/Source Code/MCAL/NVIC/: NVIC.c
    ./EGFWD_Advanced_Embedded/Source Code/MCAL/RCC/: RCC.c
    ./EGFWD_Advanced_Embedded/Source Code/MCAL/SYSTICK/: systick.c
  group APP
    ./EGFWD_Advanced_Embedded/Source Code/APP/: main.c
  group Config
    ./EGFWD_Advanced_Embedded/Source Code/Config/: IntCtrl_Cfg.c
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1, Device:Startup 1.0.1
